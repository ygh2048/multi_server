# Keil uVision project UCOS-1.uvprojx, settings and files
target UCOS-1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: UCOS-1 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\ioLibrary_Driver;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\SPI;..\HARDWARE\tcp_server_multi_socket;..\HARDWARE\wiz_interface;..\HARDWARE\wiz_platform;..\ioLibrary_Driver\Ethernet;..\ioLibrary_Driver\Application\PING;..\ioLibrary_Driver\Ethernet\W5500;..\ioLibrary_Driver\Internet\DHCP;..\HARDWARE\TIMER;..\ioLibrary_Driver\Application\loopback;..\HARDWARE\MOD_TCP_BSP;..\modbus;..\modbus\ascii;..\modbus\functions;..\modbus\include;..\modbus\rtu;..\modbus\tcp;..\modbus\port
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c task_tcp.c task_tcp.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/LCD/: lcd.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_fsmc.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group README
    ../: readme.txt
  group APP_TCP
    ../HARDWARE/wiz_platform/: wiz_platform.c
    ../HARDWARE/wiz_interface/: wiz_interface.c
    ../HARDWARE/tcp_server_multi_socket/: tcp_server_multi_socket.c
    ../ioLibrary_Driver/Application/loopback/: loopback.c
  group Ethernet
    ../ioLibrary_Driver/Ethernet/: socket.c wizchip_conf.c
    ../ioLibrary_Driver/Ethernet/W5500/: w5500.c
  group Internet
    ../ioLibrary_Driver/Internet/DHCP/: dhcp.c
  group MOD_TCP_BSP
    ../HARDWARE/MOD_TCP_BSP/: modtcpbsp.c
    ../modbus/: mb_user_reg.c
  group Modbus
    ../modbus/: mb.c
    ../modbus/ascii/: mbascii.c
    ../modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncfile.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../modbus/rtu/: mbcrc.c
    ../modbus/tcp/: mbtcp.c
    ../modbus/port/: port.h portevent.c porttcp.c
